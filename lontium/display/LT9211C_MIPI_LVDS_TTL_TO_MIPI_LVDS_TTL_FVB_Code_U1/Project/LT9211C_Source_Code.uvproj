# Keil uVision project LT9211C_Source_Code.uvproj, settings and files
target LT9211C (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LT9211C_MIPI DSI to LVDS test +hex
  c flags: Optimize=8
  c include: ..\User\Driver;..\User\App;..\User\Ocm;..\User\Module
  group Startup
    ../Startup/: STARTUP.A51
  group App
    ../User/App/: main.c
  group Ocm
    ../User/Ocm/: OcmDelay.c OcmUart0.c
  group Driver
    ../User/Driver/: DrvCsc.c DrvDcsCmd.c DrvGpio.c DrvI2cMaster.c DrvLvdsRx.c DrvLvdsTx.c DrvMipiRx.c DrvMipiTx.c DrvTtlRx.c DrvTtlTx.c DrvSystem.c DrvMipiRpt.c DrvMipiLs.c
  group Module
    ../User/Module/: ModSystem.c ModLvdsRx.c ModLvdsTx.c ModMipiRx.c ModMipiTx.c ModTtlRx.c ModTtlTx.c ModPattern.c ModMipiRpt.c ModMipiLs.c
