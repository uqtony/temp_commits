# Keil uVision project LT9611.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LT9611_RGB888_DSI_23021001 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\N76E003_Driver\inc
  group Doc
    ../Doc/: 软件修改记录.txt
  group User
    ../User/: uart0.c main.c i2c.c lt9611.c
  group Startup
    ../Startup/: STARTUP.A51
  group N76E003_driver
    ../N76E003_Driver/src/: Delay.c
